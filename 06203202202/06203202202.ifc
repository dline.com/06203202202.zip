Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-11-06T13:48:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 06 13:48:03 2017 * Host: DESKTOP-FI6EGIK * Database: C:\Users\CERTIF~1\AppData\Local\Temp\{AAC07876-F61D-4263-8445-BDE42FD1281E}\ifc * Database version: 5507 * Database creation date: Mon Nov 06 13:48:02 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 06 13:48:03 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 06 13:48:03 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: 8mm Head
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDoor: dline_Hardware_AJThumbTurn_StainlessSteel_5V90WCIndicator, 06203202202:dline_Hardware_AJThumbTurn_StainlessSteel_5V90WCIndicator:194117
In: Level 1
Type - OperationType: REVOLVING; ParameterTakesPrecedence: no; Sizeable: no
Type - 06203202202:dline_Hardware_AJThumbTurn_StainlessSteel_5V90WCIndicator:194117 - PanelOperation: REVOLVING
Type - Analytical Properties - Analytic Construction: <None>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Data - AllowedLeafThickness: n/a; C-CDistance: 30; ClassificationGradesMinimumCategoryOfUse: n/a; ClassificationGradesMinimumCorrosionResistance: n/a; ClassificationGradesMinimumDoorMass: n/a; ClassificationGradesMinimumDurability: n/a; ClassificationGradesMinimumFireResistance: n/a; ClassificationGradesMinimumSafety: n/a; ClassificationGradesMinimumSecurity: n/a; ClassificationGradesMinimumTypeOfOperation: n/a; RoseType: Solid; Spindle: n/a
Type - Dimensions - DoorLeafThickness: 40 mm; RoseDiameter: 50 mm; RoseHeight: 4.01092 mm
Type - General - Author: Gytautas Balevičius; BIMObjectName: dline_Hardware_AJThumbTurn_StainlessSteel_5V90WCIndicator; DesignCountry: Denmark; ManufacturerName: d line; ManufacturerURL: www.dline.com; MasterFormat2014Code: 08 71 00; MasterFormat2014Description: Door hardware; NBSCertification: n/a; NBSDescription: Escutcheons; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-25-38/325; NBSTypeID: n/a; OmniclassCode: 22-08 71 00; OmniclassDescription: Door Hardware; ProductFamily: Hardware; ProductGroup: Thumb turns; ProductInformation: http://dline.com/product/arne-jacobsen-collection-toilet-indicator/?attribute_pa_material=satin-stainless-steel-aisi-304&attribute_pa_item=5v90-solid-rose-cc-30-mm-assa#; ProductionCountry: Lithuania; ProductSKU: 06203202202; Revision: n/a; Uniclass2015Code: Pr_30_36_33_27; Uniclass2015Title: Escutcheons; Uniclass2015Version: Products 1.5; UNSPSCCode: 31162801; Version: 1; Weight Net (kg): 0
Type - Identity Data - Description: Arne Jacobsen design thumb turn in satin finished AISI 304 stainless steel with toilet indicator; Manufacturer: info@dline.com; Type Mark: 22; Type Name: dline_Hardware_AJThumbTurn_StainlessSteel_5V90WCIndicator
Type - Materials and Finishes - MainMaterial: AISI 304
Type - Other - AccessibilityPerformance: n/a; AssetType: fixed; Category: Pr_30_36_33_27:Escutcheons; CodePerformance: n/a; Color: n/a; Constituents: Thumb turn; Toilet indicator; DurationUnit: year; ExpectedLife: 20 years; Family Name: 06203202202; Features: n/a; Finish: Satin; Grade: n/a; Material: AISI 304 stainless steel; ModelNumber: n/a; ModelReference: 45-25-38/325; Name: dline_Hardware_AJThumbTurn_StainlessSteel_5V90WCIndicator; ReplacementCost: n/a; Shape: n/a; Size: 50 x 50 x 34 mm; SustainabilityPerformance: n/a; WarrantyDescription: 20 years (non-mechanical/-electronic parts) excluding labor; WarrantyDurationLabor: n/a; WarrantyDurationParts: 20; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: claim@dline.com
OverallHeight: 78.2641 mm; OverallWidth: 50 mm
Pset_DoorCommon - Reference: n/a; IsExternal: no; FireRating: n/a; AcousticRating: n/a; SecurityRating: n/a; HandicapAccessible: no; FireExit: no; SelfClosing: no; SmokeStop: no; GlazingAreaFraction: 0
Pset_ManufacturerTypeInformation - ModelReference: 45-25-38/325; Manufacturer: info@dline.com
Constraints - Elevation: 1219.2 mm; Host: <not associated>; Level: Level: Level 1
Dimensions - Area: 0.00227825 m2; Volume: 0.00000787505 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; BarCode: n/a; Category: Doors; Family: 06203202202: dline_Hardware_AJThumbTurn_StainlessSteel_5V90WCIndicator; Family and Type: 06203202202: dline_Hardware_AJThumbTurn_StainlessSteel_5V90WCIndicator; InstallationDate: 1900-12-31T23:59:59; Schedule Level: Level: Level 1; SerialNumber: n/a; TagNumber: n/a; Type: 06203202202: dline_Hardware_AJThumbTurn_StainlessSteel_5V90WCIndicator; Type Id: 06203202202: dline_Hardware_AJThumbTurn_StainlessSteel_5V90WCIndicator; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction
